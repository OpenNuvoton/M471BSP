# Keil uVision project ISP_UART.uvproj, settings and files
target ISP_UART (ARM-ADS)
  device: M471KI8AE Nuvoton
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x7FFFF) CLOCK(120000000) CPUTYPE("Cortex-M4") FPU2
  output: ISP_UART
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c include: ..\..\..\..\Library\Device\Nuvoton\M471\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\CMSIS\Include;..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --map --first='startup_M471.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M471/Source/: system_M471.c
    ../../../../Library/Device/Nuvoton/M471/Source/ARM/: startup_M471.s
  group User
    ../: fmc_user.c isp_user.c targetdev.c main.c uart_transfer.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c
