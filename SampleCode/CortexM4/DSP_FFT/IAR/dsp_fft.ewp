# IAR project dsp_fft.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M471 series Nuvoton M471 series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ARM_MATH_CM4=1UL; __FPU_PRESENT=1UL
  ICCARM.CCDiagSuppress: Pa082, Pa093
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\M471\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DSP_FFT.bin
  ILINK.IlinkOutputFile: DSP_FFT.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\Library\CMSIS\Lib\ARM\arm_cortexM4lf_math.lib
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M471/Source/IAR/: startup_M471.s
    ../../../../Library/Device/Nuvoton/M471/Source/: system_M471.c
  group Library
    ../../../../Library/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
    ../../../../Library/StdDriver/src/: clk.c fmc.c retarget.c sys.c uart.c
  group User
    ../: arm_fft_bin_data.c main.c
