# Keil uVision project dsp_fft.uvprojx, settings and files
target DSP_FFT (6190000::V6.19::ARMCLANG)
  device: M471KI8AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.24
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x7FFFF) CLOCK(120000000) CPUTYPE("Cortex-M4") FPU2
  output: DSP_FFT
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: ARM_MATH_CM4=1, __FPU_PRESENT=1UL
  c include: ..\..\..\..\Library\Device\Nuvoton\M471\Include;..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\CMSIS\DSP\Include;..\..\..\..\Library\CMSIS\DSP\PrivateInclude;..\..\..\..\Library\CMSIS\DSP\Source\SupportFunctions;..\..\..\..\Library\CMSIS\DSP\Source\TransformFunctions;..\..\..\..\Library\CMSIS\DSP\Source\StatisticsFunctions;..\..\..\..\Library\CMSIS\DSP\Source\ComplexMathFunctions;..\..\..\..\Library\CMSIS\DSP\Source\CommonTables
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --map --first='startup_M471.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M471/Source/: system_M471.c
    ../../../../Library/Device/Nuvoton/M471/Source/ARM/: startup_M471.s
  group User
    ../: main.c arm_fft_bin_data.c DSP_Functions.c
  group Library
    ../../../../Library/StdDriver/src/: fmc.c retarget.c uart.c clk.c sys.c
