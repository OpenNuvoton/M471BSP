# Keil uVision project BitBand.uvprojx, settings and files
target BitBand (6190000::V6.19::ARMCLANG)
  device: M471KI8AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.24
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x7FFFF) CLOCK(120000000) CPUTYPE("Cortex-M4") FPU2
  output: BitBand
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=1
  c include: ..\..\..\..\Library\Device\Nuvoton\M471\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\CMSIS\Core\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --map --first='startup_M471.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M471/Source/ARM/: startup_M471.s
    ../../../../Library/Device/Nuvoton/M471/Source/: system_M471.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c sys.c uart.c retarget.c
  group User
    ../: main.c
