# IAR project DFMC_NonBlocking.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M471 series Nuvoton M471 series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M471\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DFMC_NonBlocking.bin
  ILINK.IlinkOutputFile: DFMC_NonBlocking.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M471/Source/IAR/: startup_M471.s
    ../../../../Library/Device/Nuvoton/M471/Source/: system_M471.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c dfmc.c retarget.c sys.c timer.c uart.c
  group User
    ../: main.c
