# Keil uVision project CIR_TV_Remote_Controller.uvproj, settings and files
target CIR_TV_Remote_Controller (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: M471KI8AE Nuvoton
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x7FFFF) CLOCK(120000000) CPUTYPE("Cortex-M4") FPU2
  output: CIR_TV_Remote_Controller
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\Library\Device\Nuvoton\M471\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --map --first='startup_M471.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M471/Source/: system_M471.c
    ../../../../Library/Device/Nuvoton/M471/Source/ARM/: startup_M471.s
  group User
    ../: main.c queue.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c cir.c timer.c
